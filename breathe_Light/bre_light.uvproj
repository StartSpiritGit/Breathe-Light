# Keil uVision project bre_light.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: bre_light +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group
    ./: STARTUP.A51
  group MCU_main
    ./_80C52_MCU/scr/: _80C52_MCU_main.c
    ./_80C52_MCU/inc/: _80C52_MCU_main.h
